## main/sdkconfig.defaults
```kconfig
CONFIG_I2C_ENABLE_MASTER_SLAVE_DRIVER_NG=n
CONFIG_I2C_SKIP_LEGACY_CONFLICT_CHECK=y
```
